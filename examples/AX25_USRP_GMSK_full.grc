options:
  parameters:
    author: Julian Birk
    copyright: Julian Birk
    generate_options: qt_gui
    id: AX25_USRP_GMSK_full
    output_language: python
    title: AX25 USRP GMSK Full
  states: {}

blocks:
- name: bp_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1'
    high_cutoff_freq: '10000'
    low_cutoff_freq: '-10000'
    samp_rate: samp_rate
    type: complex_band_pass
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: carrier_freq_rec
  id: variable
  parameters:
    value: 869.45e6
  states: {}
- name: carrier_freq_send
  id: variable
  parameters:
    value: 869.55e6
  states: {}
- name: damping_ss
  id: variable
  parameters:
    value: '1'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: int(usrp_rate/samp_rate)
  states: {}
- name: loop_bw_ss
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    start: '-5000'
    step: '100'
    stop: '5000'
    value: '0'
  states: {}
- name: repeat
  id: variable
  parameters:
    value: int(usrp_rate/(symbol_rate*sps))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps*symbol_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: ted_gain_ss
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: Squelch Threshold
    start: '-100'
    step: '1'
    stop: '0'
    value: '-60'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr=192.168.10.4"'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 1000e3
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: '-60'
    type: complex
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(math.pi*2*2500)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: threshold
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.01'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(20,[1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20]) )
    period: '100000'
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: bypassed}
- name: blocks_tagged_stream_multiply_length_1
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps*repeat*8
    lengthtagname: tx_pck_len
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: bypassed}
- name: blocks_unpacked_to_packed_xx_1_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21001'
    seed: '0x0'
  states: {state: bypassed}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: '0.2'
    samps_per_sym: '10'
    type: cc
    w: '0.1'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: sps
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21001'
    seed: '0x0'
  states: {state: bypassed}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: damping_ss
    loop_bw: loop_bw_ss
    max_dev: '0.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: ted_gain_ss
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: '1'
    samp_rate: samp_rate
    taps: bp_taps
    type: ccc
  states: {}
- name: hwu_ax25_extract_frame_v2_0
  id: hwu_ax25_extract_frame_v2
  parameters: {}
  states: {}
- name: hwu_ax25_procedures_0
  id: hwu_ax25_procedures
  parameters:
    ack_timer: '1'
    dest_addr: HWUSAT
    dest_ssid: '1'
    full_duplex: 'True'
    information_field_length: '2048'
    modulo: '8'
    receive_window_k: '7'
    rej: REJ
    retries: '10'
    src_addr: HWUGND
    src_ssid: '1'
  states: {}
- name: hwu_physical_header_barker_tagged_stream_0
  id: hwu_physical_header_barker_tagged_stream
  parameters:
    add_tail: 'True'
    barker_len: '11'
    lengthtagname: tx_pck_len
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '50000'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: tx_pck_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    legend: 'False'
    name: '"Narrowband Frequency Spectrum"'
    tr_level: '-70'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: usrp_rate
    fc: '0'
    fftsize: '2048'
    name: '"Raw Received Signal"'
    plottime: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Timing Recovery
    label2: Sliced
    marker2: '7'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '2500'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: usrp_rate
    fc: '0'
    fftsize: '4096'
    int_min: '-120'
    legend: 'False'
    name: '"Full Frequency Spectrum"'
    type: complex
    update_time: '0.02'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: repeat
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    fbw: '0.4'
    interp: '1'
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '10'
    gain: '1'
    interp: '1'
    ntaps: sps*32
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: interp_fir_filter_fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: carrier_freq_send
    dev_addr: usrp_addr
    gain0: '20'
    len_tag_name: '"tx_pck_len"'
    samp_rate: usrp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: carrier_freq_rec
    dev_addr: usrp_addr
    gain0: '20'
    rx_agc0: Disabled
    samp_rate: usrp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Radio in
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Radio out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Radio in
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Radio out
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:4992
    timeout: '10000'
  states: {state: disabled}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_message_strobe_0, strobe, hwu_ax25_procedures_0, Payload in]
- [blocks_packed_to_unpacked_xx_0, '0', digital_scrambler_bb_0, '0']
- [blocks_tagged_stream_multiply_length_1, '0', uhd_usrp_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', digital_gmsk_mod_0, '0']
- [blocks_unpacked_to_packed_xx_1_0, '0', hwu_ax25_extract_frame_v2_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_descrambler_bb_0, '0']
- [digital_descrambler_bb_0, '0', blocks_unpacked_to_packed_xx_1_0, '0']
- [digital_fll_band_edge_cc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_gmsk_mod_0, '0', rational_resampler_xxx_0_0, '0']
- [digital_scrambler_bb_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_add_const_vxx_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [hwu_ax25_extract_frame_v2_0, Frame out, virtual_sink_0, '0']
- [hwu_ax25_procedures_0, Frame out, virtual_sink_1, '0']
- [hwu_ax25_procedures_0, Payload out, blocks_message_debug_0, print]
- [hwu_ax25_procedures_0, Payload out, network_socket_pdu_0, pdus]
- [hwu_physical_header_barker_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [network_socket_pdu_0, pdus, hwu_ax25_procedures_0, Payload in]
- [pdu_pdu_to_tagged_stream_0_0, '0', hwu_physical_header_barker_tagged_stream_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_tagged_stream_multiply_length_1, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0_0_0, '0', digital_fll_band_edge_cc_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_1, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0_0_0, '0']
- [virtual_source_0, '0', hwu_ax25_procedures_0, Frame in]
- [virtual_source_1, '0', pdu_pdu_to_tagged_stream_0_0, pdus]
- [zeromq_pull_msg_source_0, out, hwu_ax25_procedures_0, Payload in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-839-g7bb3846b
